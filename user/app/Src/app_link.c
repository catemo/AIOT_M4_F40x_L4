/**
 ******************************************************************************
 * @file    app_link.c
 * @brief   应用层（app）—— 阈值联动规则实现
 *
 *  接口的完整说明（功能/参数/返回值/调用处/注意事项）写在 app_link.h，
 *  本文件的注释侧重"代码是怎么实现的"。
 *
 *  全部代码只有两条三元表达式 —— 这不是因为逻辑简单而偷懒，
 *  恰恰是把"知道自己要什么"（阈值）和"知道怎么做到"（per_led）分开之后，
 *  落在这一层的职责就真的只剩这么点。
 *  ★ 如果哪天发现本文件变复杂了，多半是"业务判断"混进来了，
 *    那应该回头看看是不是职责放错了层。
 ******************************************************************************
 */
#include "module_cfg.h"
#if APP_LINK_ENABLE

#include "app_link.h"
#include "per_led.h"    /* 借 LED 链的感知层接口：编号 → 动作（跨链依赖） */

/* ========== 上一次联动的结果（边沿触发用） ==========
 * 取值：0 = 灭，1 = 亮，0xFF = 还没联动过（首帧必须写一次）
 *
 * ★ 为什么联动要"边沿触发"而不是每 2 秒都写一次：
 *   本工程里 LED1 同时被三处惦记——
 *     ① app_led 的 1 Hz 自动闪烁（用 PER_LED_Toggle 翻转）
 *     ② app_cmd 的手动 ON / OFF（串口命令）
 *     ③ 本文件的温度联动（用 PER_LED_On / Off 写绝对状态）
 *   闪烁是"翻转语义"（不管当前是亮是灭，翻一下），
 *   联动是"绝对语义"（必须亮 / 必须灭），二者天然互斥。
 *   若联动每 2 秒都写一次绝对状态，1 Hz 闪烁就被废掉了；
 *   改成【只有跨越阈值那一帧才写】，平时不碰灯，
 *   闪烁就能照常翻 —— 两条链因此得以共存。
 *   代价：跨越阈值的那一瞬间可能与闪烁的某次翻转撞车（概率极低、后果仅一瞬），
 *        对一个教学工程来说，这比"为了互斥把闪烁整个关掉"划算得多。 */
static uint8_t s_led1_state = 0xFFU;
static uint8_t s_led2_state = 0xFFU;

/*----------------------------------------------------------------------------
 * 函数功能：联动初始化（实现：先确保灯引脚已配置，再把两颗灯熄灭）
 * 调用处  ：app_dht11.c                   【接口契约见 app_link.h】
 * 注意事项：① 这里的 (void) 强转不是多余：PER_LED_On/Off 会返回错误码，
 *              本层刻意不处理——编号是编译期常量、不可能越界，
 *              若把返回值丢掉又告警，加个 (void) 表明"我确认过了"
 *           ② 顺序是"先 Init 再写状态"：Init 会把引脚配成输出，
 *              在此之前写电平无效
 *----------------------------------------------------------------------------*/
void APP_LINK_Init(void)
{
    (void)PER_LED_Init();       /* 幂等：LED 链若已初始化过，再调一次无副作用 */

    (void)PER_LED_Off(PER_LED1);   /* 温度灯：进入联动前先灭，状态确定 */
    (void)PER_LED_Off(PER_LED2);   /* 湿度灯：同上 */

    /* 状态记为"未知"而不是"灭"：这样第一帧数据到来时【必定写一次】，
     * 把"软件认为的状态"与"硬件实际状态"对齐一次。
     * 若这里直接记 0，而中途有别的代码动过灯，第一帧就会漏写。 */
    s_led1_state = 0xFFU;
    s_led2_state = 0xFFU;
}

/*----------------------------------------------------------------------------
 * 函数功能：按温度阈值联动 LED1（实现：一次比较 + 一次点/灭）
 * 调用处  ：app_dht11.c                   【接口契约见 app_link.h】
 * 注意事项：阈值来自 cfg_param.h 的 APP_LINK_TEMP_THRESHOLD，
 *           本文件不出现任何"28"这样的字面量
 *----------------------------------------------------------------------------*/
void APP_LINK_ApplyTemp(uint8_t temp_int)
{
    uint8_t want = (temp_int >= APP_LINK_TEMP_THRESHOLD) ? 1U : 0U;

    if (want == s_led1_state)
    {
        return;   /* 状态没变化：这一帧不碰灯，把 LED 让给闪烁（见文件头说明） */
    }
    s_led1_state = want;

    if (want != 0U)
    {
        (void)PER_LED_On(PER_LED1);    /* 刚跨过阈值：温度灯亮 */
    }
    else
    {
        (void)PER_LED_Off(PER_LED1);   /* 刚跌回阈值下：灭 */
    }
}

/*----------------------------------------------------------------------------
 * 函数功能：按湿度阈值联动 LED2（实现：与温度完全对称）
 * 调用处  ：app_dht11.c                   【接口契约见 app_link.h】
 *----------------------------------------------------------------------------*/
void APP_LINK_ApplyHum(uint8_t hum_int)
{
    uint8_t want = (hum_int >= APP_LINK_HUMI_THRESHOLD) ? 1U : 0U;

    if (want == s_led2_state)
    {
        return;   /* 状态没变化：不碰灯 */
    }
    s_led2_state = want;

    if (want != 0U)
    {
        (void)PER_LED_On(PER_LED2);    /* ≥ 阈值：湿度灯亮 */
    }
    else
    {
        (void)PER_LED_Off(PER_LED2);   /* 低于阈值：灭 */
    }
}

#endif /* APP_LINK_ENABLE */
